# Keil uVision project 8051_ds3232_mcp23008.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_ds3232_mcp23008 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/Lcd/: LCD_Serial.h LCD_Serial_Prototypes.h
    ./assets/i2c/: i2c.h
    ./assets/mcp23008/: mcp23008.h mcp23008_Prototypes.h
    ./assets/ds3232/: ds3232.h Time_functions.h
