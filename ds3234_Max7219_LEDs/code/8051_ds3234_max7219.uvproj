# Keil uVision project 8051_ds3234_max7219.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_ds3234_max7219 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/MAX7219/: MAX7219.h MAX7219_Prototypes.h
    ./assets/Soft_SPI/: Soft_SPI.h Soft_SPI_Pins.h
    ./assets/delay/: delay.h
    ./assets/ds3234/: ds3234_RTC.h ds3234_RTC_Prototypes.h
    ./assets/Ext_Intr/: Ext_Intr.h
