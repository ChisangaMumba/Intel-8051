# Keil uVision project 8051_SAA1064.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_saa1064_4digits +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/i2c/: i2c.h
    ./assets/delay/: delay.h
    ./assets/mcp9800/: mcp9800.h mcp9800_Prototypes.h
    ./assets/SAA1064/: SAA1064.h SAA1064_prototypes.h
