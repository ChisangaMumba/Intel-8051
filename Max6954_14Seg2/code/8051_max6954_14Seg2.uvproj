# Keil uVision project 8051_max6954_14Seg2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_max6952_14Seg2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/Soft_SPI/: Soft_SPI.h Soft_SPI_Pins.h
    ./assets/Ext_Intr/: Ext_Intr.h
    ./assets/dht22/: dht22.h dht22_prototypes.h
    ./assets/oneWIre/: oneWire.h
    ./assets/Max6954/: Max6954.h Max6954_Prototypes.h
