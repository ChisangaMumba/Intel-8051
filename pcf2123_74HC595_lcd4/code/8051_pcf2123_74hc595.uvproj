# Keil uVision project 8051_pcf2123_74hc595.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_pcf2123_74hc595_lcd4 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/74HC595/: 74HC595.h
    ./assets/soft_spi/: Soft_SPI.h Soft_SPI_Pins.h
    ./assets/delay/: delay.h
    ./assets/Lcd/: LCD_Serial.h LCD_Serial_Prototypes.h
    ./assets/pcf2123/: pcf2123.h pcf2123_prototypes.h Time_functions.h
