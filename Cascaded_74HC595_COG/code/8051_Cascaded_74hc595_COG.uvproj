# Keil uVision project 8051_Cascaded_74hc595_COG.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_Cascaded_74hc595_COG +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/74HC595/: 74HC595.h 74HC595_Protoypes.h
    ./assets/soft_spi/: Soft_SPI.h Soft_SPI_Pins.h
    ./assets/delay/: delay.h
    ./assets/TC72/: TC72.h
    ./assets/Segments/: Segments.h
