# Keil uVision project 8051_mcp9800_ht16k33.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_mcp9800_ht16k33 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/i2c/: i2c.h
    ./assets/ht16k33/: ht16k33.h ht16k33_prototypes.h
    ./assets/delay/: delay.h
    ./assets/Ext_Intr/: Ext_Intr.h
    ./assets/mcp9800/: mcp9800.h mcp9800_Prototypes.h
