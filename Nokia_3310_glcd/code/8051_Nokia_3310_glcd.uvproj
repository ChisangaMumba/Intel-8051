# Keil uVision project 8051_Nokia_3310_glcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_Nokia_3310_glcd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/soft_spi/: Soft_SPI.h Soft_SPI_Pins.h
    ./assets/delay/: delay.h
    ./assets/TC72/: TC72.h
    ./assets/nokia/: ascii_chars.h nokia_glcd.h nokia_glcd_prototypes.h image.h
