# Keil uVision project 8051_Max7219.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_Max7219 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/MAX7219/: MAX7219.h MAX7219_Prototypes.h
    ./assets/Soft_SPI/: Soft_SPI.h Soft_SPI_Pins.h
    ./assets/TC72/: TC72.h
    ./assets/delay/: delay.h
