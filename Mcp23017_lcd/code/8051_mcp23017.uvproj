# Keil uVision project 8051_mcp23017.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_mcp23017 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/Lcd/: LCD_Serial.h LCD_Serial_Prototypes.h
    ./assets/mcp23017/: mcp23017.h mcp23017_Prototypes.h
    ./assets/i2c/: i2c.h
    ./assets/lm75/: LM75.h LM75_Prototypes.h
