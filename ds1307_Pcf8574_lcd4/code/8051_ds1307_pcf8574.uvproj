# Keil uVision project 8051_ds1307_pcf8574.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_ds1307_pcf8574 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/Lcd/: LCD_Serial.h LCD_Serial_Prototypes.h
    ./assets/i2c/: i2c.h
    ./assets/pcf8574/: pcf8574.h
    ./assets/ds1307/: ds1307.h ds1307_Protoypes.h Time_functions.h
