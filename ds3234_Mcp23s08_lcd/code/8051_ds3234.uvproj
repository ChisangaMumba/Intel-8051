# Keil uVision project 8051_ds3234.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_ds3234 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/Lcd/: LCD_Serial.h LCD_Serial_Prototypes.h
    ./assets/soft_SPI/: soft_SPI.h soft_SPI_Pins.h
    ./assets/mcp23s08/: mcp23s08.h mcp23s08_Prototypes.h
    ./assets/ds3234/: ds3234_RTC.h ds3234_RTC_Prototypes.h Time_functions.h
