# Keil uVision project 8051_max6953_dotMatrix_8_digits.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_max6953_dotMatrix_8_digits +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/dht11/: dht11.h
    ./assets/oneWIre/: oneWire.h
    ./assets/Ext_Intr/: Ext_Intr.h
    ./assets/i2c/: i2c.h
    ./assets/Max6953/: Max6953.h Max6953_Prototypes.h
