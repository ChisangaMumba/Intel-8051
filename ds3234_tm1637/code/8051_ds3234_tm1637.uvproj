# Keil uVision project 8051_ds3234_tm1637.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_ds3234_tm1637 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/twoWire/: twoWire.h
    ./assets/TM1637/: TM1637.h TM1637_prototypes.h
    ./assets/ds3234/: ds3234.h ds3234_Prototypes.h Time_functions.h
    ./assets/Ext_Intr/: Ext_Intr.h
    ./assets/Soft_SPI/: Soft_SPI.h Soft_SPI_Pins.h
