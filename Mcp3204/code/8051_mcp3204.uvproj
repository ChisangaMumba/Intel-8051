# Keil uVision project 8051_mcp3204.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_mcp3204 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/max7219/: max7219.h max7219_Prototypes.h
    ./assets/soft_SPI/: soft_SPI.h soft_SPI_Pins.h
    ./assets/stdint/: stdint.h
    ./assets/mcp320x/: mcp320x.h mcp320x_prototypes.h
