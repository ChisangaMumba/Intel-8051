# Keil uVision project 8051_DHT22.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_DHT22 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/lcd4/: lcd4.h Lcd4_pins.h lcd4_prototypes.h
    ./assets/oneWIre/: oneWire.h
    ./assets/dht22/: dht22.h dht22_prototypes.h
    ./assets/delay/: delay.h
