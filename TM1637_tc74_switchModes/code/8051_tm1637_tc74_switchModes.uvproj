# Keil uVision project 8051_tm1637_tc74_switchModes.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_tm1637_tc74_switchModes +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/twoWire/: twoWire.h
    ./assets/TM1637/: TM1637.h TM1637_prototypes.h
    ./assets/Ext_Intr/: Ext_Intr.h
    ./assets/tc74/: tc74.h tc74_prototypes.h
    ./assets/i2c/: i2c.h
