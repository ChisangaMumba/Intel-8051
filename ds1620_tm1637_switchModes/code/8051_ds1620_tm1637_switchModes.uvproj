# Keil uVision project 8051_ds1620_tm1637_switchModes.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 8051_ds1620_tm1637_switchModes +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./assets/delay/: delay.h
    ./assets/twoWire/: twoWire.h
    ./assets/TM1637/: TM1637.h TM1637_prototypes.h
    ./assets/Ext_Intr/: Ext_Intr.h
    ./assets/ds1620/: ds1620.h ds1620_prototypes.h threeWire.h
